<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\xue\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\main.ewp</path>
    </project>
    <batchBuild />
</workspace>
